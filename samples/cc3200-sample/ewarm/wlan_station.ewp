# IAR project wlan_station.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; $cc3200_sdk_root$/example/common/; $cc3200_sdk_root$/driverlib/; $cc3200_sdk_root$/inc/; $cc3200_sdk_root$/oslib/; $cc3200_sdk_root$/third_party/FreeRTOS/source/; $cc3200_sdk_root$/third_party/FreeRTOS/source/include/; $cc3200_sdk_root$/third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; $cc3200_sdk_root$/simplelink/; $cc3200_sdk_root$/simplelink/source; $cc3200_sdk_root$/simplelink/include; $cc3200_sdk_root$/simplelink_extlib/provisioninglib; C:\Users\Dima\Documents\work\ulogger; C:\Users\Dima\Documents\work\platforms\cc3200; C:\Users\Dima\Documents\work\ulogger\handlers; C:\Users\Dima\Documents\work\platforms\cc3200\keen-library\keen-cc3200
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wlan_station.bin
  ILINK.IlinkOutputFile: wlan_station.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: C:\TI\CC3200SDK_1.3.0\cc3200-sdk\simplelink\ewarm\OS_debug\Exe\simplelink.a; $cc3200_sdk_root$/driverlib/ewarm/Release/Exe/driverlib.a; $cc3200_sdk_root$/oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    $cc3200_sdk_root$/example/common/: gpio_if.c network_common.c startup_ewarm.c timer_if.c uart_if.c
    ../../../platforms/cc3200/keen-library/keen-cc3200/: http_client.c http_client.h keen_client.c keen_client.h
    ../../../platforms/cc3200/: keen_handler.c keen_handler.h logging_config.h ulogger_cc3200.c ulogger_cc3200.h
    ../: main.c pinmux.c
    ../../../ulogger/handlers/: network_log_handler.c network_log_handler.h
    ../../../ulogger/: ubuffer.c ubuffer.h ulogger.c ulogger.h ulogger_events.h
